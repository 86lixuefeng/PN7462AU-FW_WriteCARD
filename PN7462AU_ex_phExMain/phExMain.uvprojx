# Keil uVision project phExMain.uvprojx, settings and files
target Debug (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: PN7462AU-C3-00 NXP
  pack: NXP.PN7xxxxx.0.9.0
  cpu: IROM(0x00203000,0x00027800) IRAM(0x00100020,0x2EE0) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: phExMain +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=$L@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 wLevel=2
  c define: PHFL_APP_NXBUILD_CONFIG __PN74XXXX__ PH_OSAL_FREERTOS
  c include: .\inc;..\PN7462AU\phCommon\inc;..\PN7462AU\phRtos\inc;..\PN7462AU\phBoot\inc;..\PN7462AU\phHal\phCfg\inc;..\PN7462AU\phHal\phhalClkGen\inc;..\PN7462AU\phHal\phhalFlash\inc;..\PN7462AU\phHal\phhalPcr\inc;..\PN7462AU\phHal\phhalPmu\inc;..\PN7462AU\phHal\phhalRf\inc;..\PN7462AU\phHal\phhalTimer\inc;..\PN7462AU\phHal\phLED\inc;..\PN7462AU\phROMIntf\phhalSysSer\inc;..\PN7462AU\phHal\phhalCt\inc;..\NxpNfcRdLib\intfs;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM0;..\PN7462AU\phpalCt\inc;.\RTE;..\DAL\boards;..\DAL\cfg;..\DAL\inc;..\phOsal\inc
  memory RVCT4: ROM 0x203000 size 0x27800
  memory RVCT9: RAM 0x100020 size 0x2ee0
  link misc: ..\PN7462AU\phHal\phhalRf\lib\libphhalRf_armcc.lib
  group Boot
    ../PN7462AU/phBoot/src/: phFlashBoot.c
    ../NxpNfcRdLib/comps/phalICode/src/: phalICode.c phalICode_Int.c
    ../NxpNfcRdLib/comps/phalICode/src/Sw/: phalICode_Sw.c
    ../NxpNfcRdLib/comps/phalMfdf/src/: phalMfdf.c phalMfdf_Int.c
  group Cfg
    ../PN7462AU/phHal/phCfg/src/: phCfg_EE.c phCfg_PF.c
  group ClkGen
    ../PN7462AU/phHal/phhalClkGen/src/: phhalClkGen.c
  group Common
    ../PN7462AU/phCommon/src/: phUser.c
  group LED
    ../PN7462AU/phHal/phLED/src/: phLED.c
  group PCR
    ../PN7462AU/phHal/phhalPcr/src/: phhalGpio.c phhalPcr.c
  group phHalRf
    ../PN7462AU/phHal/phhalRf/src/: phhalRf_Event.c phhalRf_LP_V.c
  group phExMain
    ./src/: phExMain.c phExMain_15693.c phExMain_18000p3m3.c phExMain_ActIni.c phExMain_CardMode.c phExMain_Clif.c phExMain_Ct.c phExMain_Felica.c phExMain_Jewel.c phExMain_Log.c phExMain_MiFareClassic.c phExMain_MiFareUltraLight.c phExMain_MiFareUltraLightC.c phExMain_NoRTOS.c phExMain_PasIni.c phExMain_PasTgt.c phExMain_Poll.c phExMain_Type1Tag.c phExMain_Type2Tag.c phExMain_Type3Tag.c phExMain_Type4Tag.c phExMain_TypeA_L4Exchange.c phExMain_TypeB_L4Exchange.c
  group PMU
    ../PN7462AU/phHal/phhalPmu/src/: phhalPmu.c
  group Rtos
    ../PN7462AU/phRtos/src/: phRtos_NoRtos.c phRtos_RTOS.c
    ../FreeRTOS/: croutine.c event_groups.c heap_3.c list.c phFreeRTOSConfig.c queue.c tasks.c timers.c
    ../FreeRTOS/portable/RVDS/ARM_CM0/: port.c
  group SystemServices
    ../PN7462AU/phROMIntf/phhalSysSer/src/: phhalSysSer_DS5.c
  group Timers
    ../PN7462AU/phHal/phhalTimer/src/: phhalTimer.c
  group RdLib
    ../NxpNfcRdLib/comps/phacDiscLoop/src/Sw/: phacDiscLoop_Sw.c phacDiscLoop_Sw_Int.c phacDiscLoop_Sw_Int_A.c phacDiscLoop_Sw_Int_B.c phacDiscLoop_Sw_Int_F.c phacDiscLoop_Sw_Int_I18000p3m3.c phacDiscLoop_Sw_Int_V.c
    ../NxpNfcRdLib/comps/phalFelica/src/Sw/: phalFelica_Sw.c
    ../NxpNfcRdLib/comps/phpalFelica/src/Sw/: phpalFelica_Sw.c
    ../NxpNfcRdLib/comps/phhalHw/src/: phhalHw.c
    ../NxpNfcRdLib/comps/phhalHw/src/PN7462AU/: phhalHw_PN7462AU.c phhalHw_PN7462AU_Int.c
    ../NxpNfcRdLib/comps/phpalSli15693/src/Sw/: phpalSli15693_Sw.c
    ../NxpNfcRdLib/comps/phalI18000p3m3/src/Sw/: phalI18000p3m3_Sw.c phalI18000p3m3_Sw_Int.c
    ../NxpNfcRdLib/comps/phpalI14443p3a/src/Sw/: phpalI14443p3a_Sw.c
    ../NxpNfcRdLib/comps/phpalI14443p3b/src/Sw/: phpalI14443p3b_Sw.c
    ../NxpNfcRdLib/comps/phpalI14443p4/src/Sw/: phpalI14443p4_Sw.c
    ../NxpNfcRdLib/comps/phpalI18000p3m3/src/Sw/: phpalI18000p3m3_Sw.c
    ../NxpNfcRdLib/comps/phKeyStore/src/Sw/: phKeyStore_Sw.c
    ../NxpNfcRdLib/comps/phalT1T/src/Sw/: phalT1T_Sw.c
    ../NxpNfcRdLib/comps/phKeyStore/src/: phKeyStore.c
    ../NxpNfcRdLib/comps/phalTop/src/Sw/: phalTop_Sw.c phalTop_Sw_Int_T1T.c phalTop_Sw_Int_T2T.c phalTop_Sw_Int_T3T.c phalTop_Sw_Int_T4T.c phalTop_Sw_Int_T5T.c phalTop_Sw_Int_MfcTop.c
    ../NxpNfcRdLib/comps/phalTop/src/: phalTop.c
    ../NxpNfcRdLib/comps/phpalI14443p4a/src/Sw/: phpalI14443p4a_Sw.c
    ../NxpNfcRdLib/comps/phpalI18092mPI/src/Sw/: phpalI18092mPI_Sw.c phpalI18092mPI_Sw_Int.c
    ../NxpNfcRdLib/comps/phalMfdf/src/Sw/: phalMfdf_Sw.c phalMfdf_Sw_Int.c
    ../NxpNfcRdLib/comps/phalMful/src/Sw/: phalMful_Sw.c
    ../NxpNfcRdLib/comps/phalMfc/src/Sw/: phalMfc_Sw.c
    ../NxpNfcRdLib/comps/phpalMifare/src/Sw/: phpalMifare_Sw.c
    ../NxpNfcRdLib/comps/phTools/src/: phTools.c phTools_Q.c
    ../NxpNfcRdLib/comps/phalMful/src/: phalMful.c phalMful_Int.c
    ../NxpNfcRdLib/comps/phalMfc/src/: phalMfc_Int.c
    ../NxpNfcRdLib/comps/phpalI14443p4mC/src/Sw/: phpalI14443p4mC_Sw.c phpalI14443p4mC_Sw_Int.c
    ../NxpNfcRdLib/comps/phpalI18092mT/src/Sw/: phpalI18092mT_Sw.c phpalI18092mT_Sw_Int.c
  group Ct
    ../PN7462AU/phpalCt/src/: phpalCt.c phpalCt_T0.c phpalCt_T1.c
    ../PN7462AU/phHal/phhalCt/src/: phhalCt.c phhalCt_Activate.c phhalCt_Common.c phhalCt_Event.c phhalCt_Transceive.c
  group DAL
    ../DAL/src/PN74xxxx/: phDriver_PN74xxxx.c
  group phOsal
    ../phOsal/src/Freertos/: phOsal_Freertos.c
    ../phOsal/src/NullOs/: phOsal_NullOs.c
    ../phOsal/src/NullOs/portable/: phOsal_Port_PN74xxxx.c
target Release (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: PN7462AU-C3-00 NXP
  pack: NXP.PN7xxxxx.0.9.0
  cpu: as above
  output: phExMain +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=$L@L.bin !L
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: PHFL_APP_NXBUILD_CONFIG __PN74XXXX__ PH_OSAL_FREERTOS
  c include: .\inc;..\PN7462AU\phCommon\inc;..\PN7462AU\phRtos\inc;..\PN7462AU\phBoot\inc;..\PN7462AU\phHal\phCfg\inc;..\PN7462AU\phHal\phhalClkGen\inc;..\PN7462AU\phHal\phhalFlash\inc;..\PN7462AU\phHal\phhalPcr\inc;..\PN7462AU\phHal\phhalPmu\inc;..\PN7462AU\phHal\phhalRf\inc;..\PN7462AU\phHal\phhalTimer\inc;..\PN7462AU\phHal\phLED\inc;..\PN7462AU\phROMIntf\phhalSysSer\inc;..\PN7462AU\phHal\phhalCt\inc;..\NxpNfcRdLib\intfs;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM0;..\PN7462AU\phpalCt\inc;.\RTE;..\phOsal\inc;..\DAL\inc;..\DAL\cfg;..\DAL\boards
  library: MicroLIB
  memory RVCT4: ROM 0x203000 size 0x27800
  memory RVCT9: RAM 0x100020 size 0x2ee0
  link misc: ..\PN7462AU\phHal\phhalRf\lib\libphhalRf_armcc.lib
software components: Device:Startup 0.9.0
