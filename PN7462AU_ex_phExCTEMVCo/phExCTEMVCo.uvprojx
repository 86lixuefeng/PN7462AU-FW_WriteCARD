# Keil uVision project phExCTEMVCo.uvprojx, settings and files
target Debug (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: PN7462AU-C3-00 NXP
  pack: NXP.PN7xxxxx.0.9.0
  cpu: IROM(0x00203000,0x00027800) IRAM(0x00100020,0x2EE0) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: phExCTEMVCo +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=$L@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 wLevel=2
  c define: PHFL_APP_NXBUILD_CONFIG
  c include: .\inc;..\PN7462AU\phCommon\inc;..\PN7462AU\phRtos\inc;..\PN7462AU\phBoot\inc;..\PN7462AU\phHal\phCfg\inc;..\PN7462AU\phHal\phhalClkGen\inc;..\PN7462AU\phHal\phhalFlash\inc;..\PN7462AU\phHal\phhalPcr\inc;..\PN7462AU\phHal\phhalPmu\inc;..\PN7462AU\phHal\phhalRf\inc;..\PN7462AU\phHal\phhalTimer\inc;..\PN7462AU\phHal\phLED\inc;..\PN7462AU\phROMIntf\phhalSysSer\inc;..\PN7462AU\phHal\phhalCt\inc;..\NxpNfcRdLib\intfs;..\..\external\RTOS\inc;..\..\external\RTOS\RVDS;..\PN7462AU\phpalCt\inc;.\RTE
  memory RVCT4: ROM 0x203000 size 0x27800
  memory RVCT9: RAM 0x100020 size 0x2ee0
  link misc: ..\PN7462AU\phHal\phhalRf\lib\libphhalRf_armcc.lib
  group Boot
    ../PN7462AU/phBoot/src/: phFlashBoot.c
  group Cfg
    ../PN7462AU/phHal/phCfg/src/: phCfg_EE.c phCfg_PF.c
  group ClkGen
    ../PN7462AU/phHal/phhalClkGen/src/: phhalClkGen.c
  group Common
    ../PN7462AU/phCommon/src/: phUser.c
  group LED
    ../PN7462AU/phHal/phLED/src/: phLED.c
  group PCR
    ../PN7462AU/phHal/phhalPcr/src/: phhalGpio.c phhalPcr.c
  group phHalRf
    ../PN7462AU/phHal/phhalRf/src/: phhalRf_Event.c phhalRf_LP_V.c
  group phExCTEMVCo
    ./src/: phExCTEMVCo.c
  group PMU
    ../PN7462AU/phHal/phhalPmu/src/: phhalPmu.c
  group Rtos
    ../PN7462AU/phRtos/src/: phRtos_NoRtos.c
  group SystemServices
    ../PN7462AU/phROMIntf/phhalSysSer/src/: phhalSysSer_DS5.c
  group Timers
    ../PN7462AU/phHal/phhalTimer/src/: phhalTimer.c
  group Ct
    ../PN7462AU/phpalCt/src/: phpalCt.c phpalCt_T0.c phpalCt_T1.c
    ../PN7462AU/phHal/phhalCt/src/: phhalCt.c phhalCt_Activate.c phhalCt_Common.c phhalCt_Event.c phhalCt_Transceive.c
target Release (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: PN7462AU-C3-00 NXP
  pack: NXP.PN7xxxxx.0.9.0
  cpu: as above
  output: phExCTEMVCo +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=$L@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 wLevel=2
  c define: PHFL_APP_NXBUILD_CONFIG
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x203000 size 0x27800
  memory RVCT9: RAM 0x100020 size 0x2ee0
  link misc: ..\PN7462AU\phHal\phhalRf\lib\libphhalRf_armcc.lib
software components: Device:Startup 0.9.0
