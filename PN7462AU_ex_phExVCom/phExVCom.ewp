# IAR project phExVCom.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: PN7462AU-C3-00 NXP PN7462AU-C3-00
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: PHFL_APP_NXBUILD_CONFIG; PHFL_LOG_ENABLE=0; __PN74XXXX__; PH_OSAL_FREERTOS
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: inc; ..\PN7462AU\phCommon\inc; ..\PN7462AU\phRtos\inc; ..\PN7462AU\phBoot\inc; ..\PN7462AU\phHal\phCfg\inc; ..\PN7462AU\phHal\phhalCt\inc; ..\PN7462AU\phHal\phhalClkGen\inc; ..\PN7462AU\phHal\phhalFlash\inc; ..\PN7462AU\phHal\phhalPcr\inc; ..\PN7462AU\phHal\phhalPmu\inc; ..\PN7462AU\phHal\phhalRf\inc; ..\PN7462AU\phHal\phhalTimer\inc; ..\PN7462AU\phHal\phLED\inc; ..\PN7462AU\phROMIntf\phhalSysSer\inc; ..\FreeRTOS\include; ..\FreeRTOS\portable\IAR\ARM_CM0; ..\NxpNfcRdLib\intfs; ..\PN7462AU\external\CDCLib\inc; ..\PN7462AU\external\USBD_ROMStack\inc; ..\PN7462AU\phHal\phhalHif\inc; ..\PN7462AU\phHal\phhalWdt\inc; ..\PN7462AU\external\CDCLib\ext\inc; ..\DAL\boards; ..\DAL\cfg; ..\DAL\inc; ..\phOsal\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: ..\PN7462AU\phCommon\inc; ..\FreeRTOS\include; inc; ..\PN7462AU\external\CDCLib\inc; ..\PN7462AU\external\USBD_ROMStack\inc; ..\PN7462AU\external\CDCLib\ext\inc
  OBJCOPY.OOCOutputFile: phExVCom.bin
  ILINK.IlinkOutputFile: phExVCom.out
  ILINK.IlinkExtraOptions: --checksum __vector_table+0xFC:4,crc32:1;__vector_table-__vector_table+0xFC
  ILINK.IlinkAdditionalLibs: ..\PN7462AU\phHal\phhalRf\lib\libphhalRf_iccarm.a; ..\PN7462AU\external\USBD_ROMStack\lib\libusbd_iccarm.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; PHFL_APP_NXBUILD_CONFIG; PHFL_LOG_ENABLE=0; __PN74XXXX__; PH_OSAL_FREERTOS
  ICCARM.CCIncludePath2: inc; ..\PN7462AU\phCommon\inc; ..\PN7462AU\phRtos\inc; ..\PN7462AU\phBoot\inc; ..\PN7462AU\phHal\phCfg\inc; ..\PN7462AU\phHal\phhalCt\inc; ..\PN7462AU\phHal\phhalClkGen\inc; ..\PN7462AU\phHal\phhalFlash\inc; ..\PN7462AU\phHal\phhalPcr\inc; ..\PN7462AU\phHal\phhalPmu\inc; ..\PN7462AU\phHal\phhalRf\inc; ..\PN7462AU\phHal\phhalTimer\inc; ..\PN7462AU\phHal\phLED\inc; ..\PN7462AU\phROMIntf\phhalSysSer\inc; ..\FreeRTOS\include; ..\FreeRTOS\portable\IAR\ARM_CM0; ..\NxpNfcRdLib\intfs; ..\PN7462AU\external\USBD_ROMStack\inc; ..\PN7462AU\external\CDCLib\inc; ..\PN7462AU\phHal\phhalHif\inc; ..\PN7462AU\phHal\phhalWdt\inc; ..\PN7462AU\external\CDCLib\ext\inc; ..\DAL\boards; ..\DAL\cfg; ..\DAL\inc; ..\phOsal\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group DAL
    ../DAL/src/PN74xxxx/: phDriver_PN74xxxx.c
  group external/CDCLib/ext/inc
    ../PN7462AU/external/CDCLib/ext/inc/: app_usbd_cfg.h cdc_vcom.h usbd_cdc.h usbd_cdc_str.h usbd_cdcuser.h
  group external/CDCLib/ext/src
    ../PN7462AU/external/CDCLib/ext/src/: cdc_desc.c cdc_user.c cdc_vcom.c
  group external/CDCLib/inc
    ../PN7462AU/external/CDCLib/inc/: VComInterface.h
  group external/CDCLib/src
    ../PN7462AU/external/CDCLib/src/: cdc_main.c
  group external/FreeRTOS_Library
    ../FreeRTOS/: event_groups.c heap_2.c list.c phFreeRTOSConfig.c queue.c tasks.c timers.c
  group external/FreeRTOS_Library/include
    ../FreeRTOS/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h FreeRTOSConfig.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group external/FreeRTOS_Library/portable/IAR/ARM_CM0
    ../FreeRTOS/portable/IAR/ARM_CM0/: port.c portasm.s portmacro.h
  group inc
    inc/: APP_NxpBuild.h phExVCom.h phExVCom_Cfg.h phExVCom_PollTypeA.h
  group NxpNfcLib/comps/phhalHw/src
    ../NxpNfcRdLib/comps/phhalHw/src/: phhalHw.c
  group NxpNfcLib/comps/phhalHw/src/PN7462AU
    ../NxpNfcRdLib/comps/phhalHw/src/PN7462AU/: phhalHw_PN7462AU.c phhalHw_PN7462AU.h phhalHw_PN7462AU_Int.c phhalHw_PN7462AU_Int.h
  group NxpNfcLib/intfs
    ../NxpNfcRdLib/intfs/: NxpRdLib_Ver.h phacDiscLoop.h phalFelica.h phalI15693.h phalI18000p3m3.h phalMfc.h phalMfdf.h phalMful.h phalT1T.h phalTop.h phceT4T.h phhalHw.h phKeyStore.h phlnLlcp.h phLog.h phnpSnep.h phOsal.h phpalEpcUid.h phpalFelica.h phpalI14443p3a.h phpalI14443p3b.h phpalI14443p4.h phpalI14443p4a.h phpalI14443p4mC.h phpalI18000p3m3.h phpalI18092mPI.h phpalI18092mT.h phpalMifare.h phpalSli15693.h phPlatform.h phTools.h
  group phCommon/inc
    ../PN7462AU/phCommon/inc/: ph_BinaryNumbers.h ph_Config.h ph_Datatypes.h ph_Log.h ph_MemoryMap.h ph_NxpBuild.h ph_NxpBuild_Default.h ph_Platform.h ph_RefDefs.h ph_Reg.h ph_Status.h ph_TypeDefs.h phCfg_EE.h phFlashBoot.h phFlashBoot_Event.h phhalClkGen.h phhalCrc.h phhalCt.h phhalEeprom.h phhalFlash.h phhalGpio.h phhalHif.h phhalHif_Usb.h phhalI2CM.h phhalNvic.h phhalPcr.h phhalPmu.h phhalRf.h phhalRf_LP_Int.h phhalRng.h phhalSPIM.h phhalSyncCt.h phhalSyncCt_I2C.h phhalSyncCt_S10.h phhalSyncCt_S9.h phhalSysSer.h phhalTimer.h phhalWdt.h phLED.h phRtos.h phSysSv_Data.h phUser.h PN7462AU_ROM3.h PN7462AU_Ver.h
  group phCommon/inc/PN7462AU
    ../PN7462AU/phCommon/inc/PN7462AU/: PN7462AU_clif.h PN7462AU_clkgen.h PN7462AU_crc.h PN7462AU_ctip.h PN7462AU_eectrl.h PN7462AU_hif.h PN7462AU_i2cm.h PN7462AU_pcr.h PN7462AU_pmu.h PN7462AU_regcore.h PN7462AU_rng.h PN7462AU_spim.h PN7462AU_timers.h PN7462AU_usb.h
  group phCommon/inc/wrapper
    ../PN7462AU/phCommon/inc/wrapper/: phRtos_NoRtos.h phRtos_RTOS.h
  group phCommon/src
    ../PN7462AU/phCommon/src/: phUser.c
  group phOsal
    ../phOsal/src/Freertos/: phOsal_Freertos.c
    ../phOsal/src/NullOs/: phOsal_NullOs.c
    ../phOsal/src/NullOs/portable/: phOsal_Port_PN74xxxx.c
  group phRtos/src
    ../PN7462AU/phRtos/src/: phRtos_NoRtos.c phRtos_RTOS.c
  group PN7462AU/phBoot/src
    ../PN7462AU/phBoot/src/: phFlashBoot.c phFlashBoot_IAR.s phFlashBoot_VT.c
  group PN7462AU/phHal/phCfg/src
    ../PN7462AU/phHal/phCfg/src/: phCfg_EE.c phCfg_PF.c
  group PN7462AU/phHal/phhalClkGen/src
    ../PN7462AU/phHal/phhalClkGen/src/: phhalClkGen.c
  group PN7462AU/phHal/phhalCt/inc
    ../PN7462AU/phHal/phhalCt/inc/: phhalCt.h
  group PN7462AU/phHal/phhalCt/src
    ../PN7462AU/phHal/phhalCt/src/: phhalCt.c phhalCt_Activate.c phhalCt_Common.c phhalCt_Event.c phhalCt_Event.h phhalCt_Int.h phhalCt_Transceive.c
  group PN7462AU/phHal/phhalFlash/src
    ../PN7462AU/phHal/phhalFlash/src/: phhalFlash.c
  group PN7462AU/phHal/phhalHif/src
    ../PN7462AU/phHal/phhalHif/src/: phhalHif_Usb.c
  group PN7462AU/phHal/phhalPcr/src
    ../PN7462AU/phHal/phhalPcr/src/: phhalGpio.c phhalPcr.c
  group PN7462AU/phHal/phhalPmu/src
    ../PN7462AU/phHal/phhalPmu/src/: phhalPmu.c
  group PN7462AU/phHal/phhalRf/src
    ../PN7462AU/phHal/phhalRf/src/: phhalRf_Event.c phhalRf_Event.h phhalRf_LP_V.c phhalRf_LP_V.h
  group PN7462AU/phHal/phhalTimer/src
    ../PN7462AU/phHal/phhalTimer/src/: phhalTimer.c phhalTimer_Int.h
  group PN7462AU/phHal/phhalWdt/inc
    ../PN7462AU/phHal/phhalWdt/inc/: phhalWdt.h
  group PN7462AU/phHal/phhalWdt/src
    ../PN7462AU/phHal/phhalWdt/src/: phhalWdt.c
  group PN7462AU/phHal/phLED/src
    ../PN7462AU/phHal/phLED/src/: phLED.c
  group PN7462AU/phROMIntf/phhalSysSer/src
    ../PN7462AU/phROMIntf/phhalSysSer/src/: phhalSysSer_IAR.s
  group src
    src/: phExVCom.c phExVCom_PollTypeA.c
