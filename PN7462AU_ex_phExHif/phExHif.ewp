# IAR project phExHif.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: PN7462AU-C3-00 NXP PN7462AU-C3-00
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: PHFL_APP_NXBUILD_CONFIG; __PN74XXXX__
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: inc; ..\PN7462AU\phCommon\inc; ..\PN7462AU\phRtos\inc; ..\PN7462AU\phBoot\inc; ..\PN7462AU\phHal\phCfg\inc; ..\PN7462AU\phHal\phhalCt\inc; ..\PN7462AU\phHal\phhalClkGen\inc; ..\PN7462AU\phHal\phhalFlash\inc; ..\PN7462AU\phHal\phhalPcr\inc; ..\PN7462AU\phHal\phhalPmu\inc; ..\PN7462AU\phHal\phhalTimer\inc; ..\PN7462AU\phHal\phLED\inc; ..\PN7462AU\phROMIntf\phhalSysSer\inc; ..\PN7462AU\phpalCt\inc; ..\PN7462AU\phHal\phhalHif\inc; ..\PN7462AU\phHal\phhalI2CM\inc; ..\PN7462AU\phHal\phhalSPIM\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: PHFL_APP_NXBUILD_CONFIG; __PN74XXXX__
  AARM.AUserIncludes: ..\PN7462AU\phCommon\inc; ..\FreeRTOS\include; inc
  OBJCOPY.OOCOutputFile: phExHif.bin
  ILINK.IlinkOutputFile: phExHif.out
  ILINK.IlinkExtraOptions: --checksum __vector_table+0xFC:4,crc32:1;__vector_table-__vector_table+0xFC
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; PHFL_APP_NXBUILD_CONFIG; __PN74XXXX__
  group inc
    inc/: APP_NxpBuild.h phExHif.h phExHif_Hw.h
  group NxpCtLib/phpalCt/inc
    ../PN7462AU/phpalCt/inc/: phpalCt.h
  group NxpCtLib/phpalCt/src
    ../PN7462AU/phpalCt/src/: phpalCt.c phpalCt_T0.c phpalCt_T0.h phpalCt_T1.c phpalCt_T1.h
  group phCommon/inc
    ../PN7462AU/phCommon/inc/: ph_BinaryNumbers.h ph_Config.h ph_Datatypes.h ph_Log.h ph_MemoryMap.h ph_NxpBuild.h ph_NxpBuild_Default.h ph_Platform.h ph_RefDefs.h ph_Reg.h ph_Status.h ph_TypeDefs.h phCfg_EE.h phFlashBoot.h phFlashBoot_Event.h phhalClkGen.h phhalCrc.h phhalCt.h phhalEeprom.h phhalFlash.h phhalGpio.h phhalHif.h phhalHif_Usb.h phhalI2CM.h phhalNvic.h phhalPcr.h phhalPmu.h phhalRf.h phhalRf_LP_Int.h phhalRng.h phhalSPIM.h phhalSyncCt.h phhalSyncCt_I2C.h phhalSyncCt_S10.h phhalSyncCt_S9.h phhalSysSer.h phhalTimer.h phhalWdt.h phLED.h phRtos.h phSysSv_Data.h phUser.h PN7462AU_ROM3.h PN7462AU_Ver.h
  group phCommon/inc/PN7462AU
    ../PN7462AU/phCommon/inc/PN7462AU/: PN7462AU_clif.h PN7462AU_clkgen.h PN7462AU_crc.h PN7462AU_ctip.h PN7462AU_eectrl.h PN7462AU_hif.h PN7462AU_i2cm.h PN7462AU_pcr.h PN7462AU_pmu.h PN7462AU_regcore.h PN7462AU_rng.h PN7462AU_spim.h PN7462AU_timers.h PN7462AU_usb.h
  group phCommon/inc/wrapper
    ../PN7462AU/phCommon/inc/wrapper/: phRtos_NoRtos.h phRtos_RTOS.h
  group phCommon/src
    ../PN7462AU/phCommon/src/: phUser.c
  group phRtos/src
    ../PN7462AU/phRtos/src/: phRtos_NoRtos.c
  group PN7462AU/phBoot/src
    ../PN7462AU/phBoot/src/: phFlashBoot.c phFlashBoot_IAR.s phFlashBoot_VT.c
  group PN7462AU/phHal/phCfg/src
    ../PN7462AU/phHal/phCfg/src/: phCfg_EE.c phCfg_PF.c
  group PN7462AU/phHal/phhalClkGen/src
    ../PN7462AU/phHal/phhalClkGen/src/: phhalClkGen.c
  group PN7462AU/phHal/phhalCt/src
    ../PN7462AU/phHal/phhalCt/src/: phhalCt.c phhalCt_Activate.c phhalCt_Common.c phhalCt_Event.c phhalCt_Event.h phhalCt_Int.h phhalCt_Transceive.c
  group PN7462AU/phHal/phhalFlash/src
    ../PN7462AU/phHal/phhalFlash/src/: phhalFlash.c
  group PN7462AU/phHal/phhalHif/src
    ../PN7462AU/phHal/phhalHif/src/: phhalHif.c phhalHif_Int.h
  group PN7462AU/phHal/phhalI2CM/src
    ../PN7462AU/phHal/phhalI2CM/src/: phhalI2CM.c phhalI2CM_Event.c phhalI2CM_Event.h phhalI2CM_FillCopyFifo.h phhalI2CM_FillCopyFifo_IAR.s phhalI2CM_Int.h
  group PN7462AU/phHal/phhalPcr/src
    ../PN7462AU/phHal/phhalPcr/src/: phhalGpio.c phhalPcr.c
  group PN7462AU/phHal/phhalPmu/src
    ../PN7462AU/phHal/phhalPmu/src/: phhalPmu.c
  group PN7462AU/phHal/phhalSPIM/src
    ../PN7462AU/phHal/phhalSPIM/src/: phhalSPIM.c phhalSPIM_Event.c phhalSPIM_Event.h phhalSPIM_Int.h
  group PN7462AU/phHal/phhalSyncCt/src
    ../PN7462AU/phHal/phhalSyncCt/src/: phhalSyncCt.c phhalSyncCt_I2C.c phhalSyncCt_S10.c phhalSyncCt_S9.c
  group PN7462AU/phHal/phhalTimer/src
    ../PN7462AU/phHal/phhalTimer/src/: phhalTimer.c phhalTimer_Int.h
  group PN7462AU/phHal/phhalWdt/src
    ../PN7462AU/phHal/phhalWdt/src/: phhalWdt.c
  group PN7462AU/phHal/phLED/src
    ../PN7462AU/phHal/phLED/src/: phLED.c
  group PN7462AU/phROMIntf/phhalSysSer/src
    ../PN7462AU/phROMIntf/phhalSysSer/src/: phhalSysSer_IAR.s
  group src
    src/: phExHif.c phExHif_Hw.c
