# Keil uVision project phExHif.uvprojx, settings and files
target Debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PN7462AU-C3-00 NXP
  pack: NXP.PN7xxxxx.0.9.0
  cpu: IROM(0x00203000,0x00027800) IROM2(0x00201200,0x00000E00) IRAM(0x00100020,0x2EE0) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: phExHif +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=$L@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 wLevel=2
  c define: PHFL_APP_NXBUILD_CONFIG
  c include: .\inc;..\PN7462AU\phCommon\inc;..\PN7462AU\phRtos\inc;..\PN7462AU\phBoot\inc;..\PN7462AU\phHal\phCfg\inc;..\PN7462AU\phHal\phhalClkGen\inc;..\PN7462AU\phHal\phhalFlash\inc;..\PN7462AU\phHal\phhalPcr\inc;..\PN7462AU\phHal\phhalPmu\inc;..\PN7462AU\phHal\phhalRf\inc;..\PN7462AU\phHal\phhalTimer\inc;..\PN7462AU\phHal\phLED\inc;..\PN7462AU\phROMIntf\phhalSysSer\inc
  memory RVCT4: ROM 0x203000 size 0x27800
  memory RVCT5: ROM 0x201200 size 0xe00
  memory RVCT9: RAM 0x100020 size 0x2ee0
  link misc: ..\PN7462AU\phHal\phhalRf\lib\libphhalRf_armcc.lib
  group Boot
    ../PN7462AU/phBoot/src/: phFlashBoot.c
  group Cfg
    ../PN7462AU/phHal/phCfg/src/: phCfg_EE.c phCfg_PF.c
  group ClkGen
    ../PN7462AU/phHal/phhalClkGen/src/: phhalClkGen.c
  group Common
    ../PN7462AU/phCommon/src/: phUser.c
  group LED
    ../PN7462AU/phHal/phLED/src/: phLED.c
  group PCR
    ../PN7462AU/phHal/phhalPcr/src/: phhalGpio.c phhalPcr.c
  group phHalRf
    ../PN7462AU/phHal/phhalRf/src/: phhalRf_Event.c phhalRf_LP_V.c
  group phExHif
    ./src/: phExHif.c phExHif_Hw.c
  group PMU
    ../PN7462AU/phHal/phhalPmu/src/: phhalPmu.c
  group Rtos
    ../PN7462AU/phRtos/src/: phRtos_NoRtos.c
  group SystemServices
    ../PN7462AU/phROMIntf/phhalSysSer/src/: phhalSysSer_DS5.c
  group Timers
    ../PN7462AU/phHal/phhalTimer/src/: phhalTimer.c
  group Ct
    ../PN7462AU/phpalCt/src/: phpalCt.c phpalCt_T0.c phpalCt_T1.c
    ../PN7462AU/phHal/phhalCt/src/: phhalCt.c phhalCt_Activate.c phhalCt_Common.c phhalCt_Event.c phhalCt_Transceive.c
  group phHal
    ../PN7462AU/phHal/phhalHif/src/: phhalHif.c
    ../PN7462AU/phHal/phhalFlash/src/: phhalFlash.c
    ../PN7462AU/phHal/phhalI2CM/src/: phhalI2CM.c phhalI2CM_Event.c phhalI2CM_FillCopyFifo.c
    ../PN7462AU/phHal/phhalSPIM/src/: phhalSPIM.c phhalSPIM_Event.c
target Release (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: PN7462AU-C3-00 NXP
  pack: NXP.PN7xxxxx.0.9.0
  cpu: IROM(0x00203000,0x00027800) IRAM(0x00100020,0x2EE0) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: phExHif +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=$L@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 wLevel=2
  c define: PHFL_APP_NXBUILD_CONFIG
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x203000 size 0x27800
  memory RVCT9: RAM 0x100020 size 0x2ee0
  link misc: ..\PN7462AU\phHal\phhalRf\lib\libphhalRf_armcc.lib
software components: Device:Startup 0.9.0
