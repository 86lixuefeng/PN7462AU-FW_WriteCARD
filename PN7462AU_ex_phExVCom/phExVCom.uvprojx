# Keil uVision project phExVCom.uvprojx, settings and files
target Debug (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: PN7462AU-C3-00 NXP
  pack: NXP.PN7xxxxx.0.9.0
  cpu: IROM(0x00203000,0x00027800) IRAM(0x00100020,0x2EE0) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: phExVCom
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=$L@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 wLevel=2
  c define: __PN74XXXX__ PHFL_APP_NXBUILD_CONFIG PHFL_LOG_ENABLE=0 PH_OSAL_FREERTOS
  c misc: --diag_suppress=1295
  c include: ..\PN7462AU\external\USBD_ROMStack\inc;..\PN7462AU\phCommon\inc;..\NxpNfcRdLib\intfs;..\PN7462AU\phBoot\inc;..\PN7462AU\phHal\phCfg\inc;..\PN7462AU\phHal\phLED\inc;..\PN7462AU\phHal\phhalClkGen\inc;..\PN7462AU\phHal\phhalCrc\inc;..\PN7462AU\phHal\phhalCt\inc;..\PN7462AU\phHal\phhalEeprom\inc;..\PN7462AU\phHal\phhalFlash\inc;..\PN7462AU\phHal\phhalHif\inc;..\PN7462AU\phHal\phhalI2CM\inc;..\PN7462AU\phHal\phhalPcr\inc;..\PN7462AU\phHal\phhalPmu\inc;..\PN7462AU\phHal\phhalRf\inc;..\PN7462AU\phHal\phhalRng\inc;..\PN7462AU\phHal\phhalSPIM\inc;..\PN7462AU\phHal\phhalSyncCt\inc;..\PN7462AU\phHal\phhalSyncCt\inc;..\PN7462AU\phHal\phhalTimer\inc;..\PN7462AU\phHal\phhalWdt\inc;..\PN7462AU\phROMIntf\phhalSysSer\inc;..\FreeRTOS\include;..\PN7462AU\phRtos\inc;..\FreeRTOS\portable\RVDS\ARM_CM0;.\inc;..\PN7462AU\external\CDCLib\inc;..\PN7462AU\external\CDCLib\ext\inc;..\DAL\boards;..\DAL\cfg;..\DAL\inc;..\phOsal\inc
  library: MicroLIB
  memory RVCT4: ROM 0x203000 size 0x27800
  memory RVCT9: RAM 0x100020 size 0x2ee0
  link misc: ..\PN7462AU\phHal\phhalRf\lib\libphhalRf_armcc.lib ..\PN7462AU\external\USBD_ROMStack\lib\libusbd_armcc.lib
  group NxpNfcLib-HAL
    ../NxpNfcRdLib/comps/phhalHw/src/: phhalHw.c
    ../NxpNfcRdLib/comps/phhalHw/src/PN7462AU/: phhalHw_PN7462AU.c phhalHw_PN7462AU_Int.c
  group external-Rtos
    ../FreeRTOS/: event_groups.c heap_3.c list.c queue.c tasks.c timers.c phFreeRTOSConfig.c
    ../FreeRTOS/portable/RVDS/ARM_CM0/: port.c
  group Boot
    ../PN7462AU/phBoot/src/: phFlashBoot.c
  group Cfg
    ../PN7462AU/phHal/phCfg/src/: phCfg_EE.c phCfg_PF.c
  group ClkGen
    ../PN7462AU/phHal/phhalClkGen/src/: phhalClkGen.c
  group Common
    ../PN7462AU/phCommon/src/: phUser.c
  group Hif
    ../PN7462AU/phHal/phhalHif/src/: phhalHif_Usb.c
  group LED
    ../PN7462AU/phHal/phLED/src/: phLED.c
  group PCR
    ../PN7462AU/phHal/phhalPcr/src/: phhalGpio.c phhalPcr.c
  group Rf
    ../PN7462AU/phHal/phhalRf/src/: phhalRf_Event.c phhalRf_LP_V.c
  group PMU
    ../PN7462AU/phHal/phhalPmu/src/: phhalPmu.c
  group Rtos
    ../PN7462AU/phRtos/src/: phRtos_NoRtos.c phRtos_RTOS.c
  group SystemServices
    ../PN7462AU/phROMIntf/phhalSysSer/src/: phhalSysSer_DS5.c
  group Timers
    ../PN7462AU/phHal/phhalTimer/src/: phhalTimer.c
  group src
    ./src/: phExVCom.c phExVCom_PollTypeA.c
  group external-UsbCdc
    ../PN7462AU/external/CDCLib/src/: cdc_main.c
    ../PN7462AU/external/CDCLib/ext/src/: cdc_desc.c cdc_user.c cdc_vcom.c
  group DAL
    ../DAL/src/PN74xxxx/: phDriver_PN74xxxx.c
  group phOsal
    ../phOsal/src/Freertos/: phOsal_Freertos.c
    ../phOsal/src/NullOs/: phOsal_NullOs.c
    ../phOsal/src/NullOs/portable/: phOsal_Port_PN74xxxx.c
target Release (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: PN7462AU-C3-00 NXP
  pack: NXP.PN7xxxxx.0.9.0
  cpu: as above
  output: phExVCom
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=$L@L.bin !L
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: as above
  c misc: --diag_suppress=1295
  c include: ..\PN7462AU\external\USBD_ROMStack\inc;..\PN7462AU\phCommon\inc;..\NxpNfcRdLib\intfs;..\PN7462AU\phBoot\inc;..\PN7462AU\phHal\phCfg\inc;..\PN7462AU\phHal\phLED\inc;..\PN7462AU\phHal\phhalClkGen\inc;..\PN7462AU\phHal\phhalCrc\inc;..\PN7462AU\phHal\phhalCt\inc;..\PN7462AU\phHal\phhalEeprom\inc;..\PN7462AU\phHal\phhalFlash\inc;..\PN7462AU\phHal\phhalHif\inc;..\PN7462AU\phHal\phhalI2CM\inc;..\PN7462AU\phHal\phhalPcr\inc;..\PN7462AU\phHal\phhalPmu\inc;..\PN7462AU\phHal\phhalRf\inc;..\PN7462AU\phHal\phhalRng\inc;..\PN7462AU\phHal\phhalSPIM\inc;..\PN7462AU\phHal\phhalSyncCt\inc;..\PN7462AU\phHal\phhalTimer\inc;..\PN7462AU\phHal\phhalWdt\inc;..\PN7462AU\phROMIntf\phhalSysSer\inc;..\FreeRTOS\include;.\inc;..\PN7462AU\phRtos\inc;..\FreeRTOS\portable\RVDS\ARM_CM0;..\PN7462AU\external\CDCLib\inc;..\PN7462AU\external\CDCLib\ext\inc;..\DAL\boards;..\DAL\inc;..\DAL\cfg;..\phOsal\inc
  library: MicroLIB
  memory RVCT4: ROM 0x203000 size 0x27800
  memory RVCT9: RAM 0x100020 size 0x2ee0
  link misc: as above
software components: Device:Startup 0.9.0
