# IAR project phExPos.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: PN7462AU-C3-00 NXP PN7462AU-C3-00
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: PHFL_APP_NXBUILD_CONFIG; __PN74XXXX__; PH_OSAL_FREERTOS
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: inc; ..\PN7462AU\phCommon\inc; ..\PN7462AU\phRtos\inc; ..\PN7462AU\phBoot\inc; ..\PN7462AU\phHal\phCfg\inc; ..\PN7462AU\phHal\phhalCt\inc; ..\PN7462AU\phHal\phhalClkGen\inc; ..\PN7462AU\phHal\phhalFlash\inc; ..\PN7462AU\phHal\phhalHif\inc; ..\PN7462AU\phHal\phhalPcr\inc; ..\PN7462AU\phHal\phhalPmu\inc; ..\PN7462AU\phHal\phhalRf\inc; ..\PN7462AU\phHal\phhalTimer\inc; ..\PN7462AU\phHal\phLED\inc; ..\PN7462AU\phHal\phhalWdt\inc; ..\PN7462AU\phROMIntf\phhalSysSer\inc; ..\FreeRTOS\include; ..\FreeRTOS\portable\IAR\ARM_CM0; ..\NxpNfcRdLib\intfs; ..\PN7462AU\phpalCt\inc; ..\DAL\boards; ..\DAL\cfg; ..\DAL\inc; ..\phOsal\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: PHFL_APP_NXBUILD_CONFIG; PHFL_LOG_ENABLE=0; __PN74XXXX__; PH_OSAL_FREERTOS
  AARM.AUserIncludes: ..\PN7462AU\phCommon\inc; ..\FreeRTOS\include; inc; ..\FreeRTOS\include; ..\FreeRTOS\portable\IAR\ARM_CM0
  OBJCOPY.OOCOutputFile: phExPos.bin
  ILINK.IlinkOutputFile: phExPos.out
  ILINK.IlinkExtraOptions: --checksum __vector_table+0xFC:4,crc32:1;__vector_table-__vector_table+0xFC
  ILINK.IlinkAdditionalLibs: ..\PN7462AU\phHal\phhalRf\lib\libphhalRf_iccarm.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; PHFL_APP_NXBUILD_CONFIG; __PN74XXXX__; PH_OSAL_FREERTOS
  ICCARM.CCIncludePath2: inc; ..\PN7462AU\phCommon\inc; ..\PN7462AU\phRtos\inc; ..\PN7462AU\phBoot\inc; ..\PN7462AU\phHal\phCfg\inc; ..\PN7462AU\phHal\phhalCt\inc; ..\PN7462AU\phHal\phhalClkGen\inc; ..\PN7462AU\phHal\phhalFlash\inc; ..\PN7462AU\phHal\phhalHif\inc; ..\PN7462AU\phHal\phhalPcr\inc; ..\PN7462AU\phHal\phhalPmu\inc; ..\PN7462AU\phHal\phhalRf\inc; ..\PN7462AU\phHal\phhalTimer\inc; ..\PN7462AU\phHal\phLED\inc; ..\PN7462AU\phHal\phhalWdt\inc; ..\PN7462AU\phROMIntf\phhalSysSer\inc; ..\FreeRTOS\include; ..\FreeRTOS\portable\IAR\ARM_CM0; ..\NxpNfcRdLib\intfs; ..\PN7462AU\phpalCt\inc; ..\phOsal\inc; ..\DAL\boards; ..\DAL\cfg; ..\DAL\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.AUserIncludes: ..\PN7462AU\phCommon\inc; ..\FreeRTOS\include; inc
  group DAL
    ../DAL/src/PN74xxxx/: phDriver_PN74xxxx.c
  group external/RTOS/IAR
    ../FreeRTOS/portable/IAR/ARM_CM0/: port.c portasm.s portmacro.h
  group external/RTOS/inc
    ../FreeRTOS/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h FreeRTOSConfig.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group external/RTOS/src
    ../FreeRTOS/: event_groups.c heap_2.c list.c queue.c tasks.c timers.c
  group inc
    inc/: APP_NxpBuild.h phExPos.h phExPos_Cfg.h phExPos_Clif.h phExPos_Common.h phExPos_Ct.h phExPos_NoRTOS.h phExPos_Poll.h phExPos_SPIHIF.h phExPos_TypeAEMV.h phExPos_Utils.h
  group NxpCtLib/phpalCt/inc
    ../PN7462AU/phpalCt/inc/: phpalCt.h
  group NxpCtLib/phpalCt/src
    ../PN7462AU/phpalCt/src/: phpalCt.c phpalCt_T0.c phpalCt_T0.h phpalCt_T1.c phpalCt_T1.h
  group NxpNfcLib/comps/phacDiscLoop/src
    ../NxpNfcRdLib/comps/phacDiscLoop/src/: phacDiscLoop.c
  group NxpNfcLib/comps/phacDiscLoop/src/Sw
    ../NxpNfcRdLib/comps/phacDiscLoop/src/Sw/: phacDiscLoop_Sw.c phacDiscLoop_Sw.h phacDiscLoop_Sw_Int.c phacDiscLoop_Sw_Int.h phacDiscLoop_Sw_Int_A.c phacDiscLoop_Sw_Int_A.h phacDiscLoop_Sw_Int_B.c phacDiscLoop_Sw_Int_B.h phacDiscLoop_Sw_Int_F.c phacDiscLoop_Sw_Int_F.h phacDiscLoop_Sw_Int_I18000p3m3.c phacDiscLoop_Sw_Int_I18000p3m3.h phacDiscLoop_Sw_Int_V.c phacDiscLoop_Sw_Int_V.h
  group NxpNfcLib/comps/phalFelica/src
    ../NxpNfcRdLib/comps/phalFelica/src/: phalFelica.c phalFelica_Int.h
  group NxpNfcLib/comps/phalFelica/src/Sw
    ../NxpNfcRdLib/comps/phalFelica/src/Sw/: phalFelica_Sw.c phalFelica_Sw.h
  group NxpNfcLib/comps/phalI18000p3m3/src
    ../NxpNfcRdLib/comps/phalI18000p3m3/src/: phalI18000p3m3.c
  group NxpNfcLib/comps/phalI18000p3m3/src/Sw
    ../NxpNfcRdLib/comps/phalI18000p3m3/src/Sw/: phalI18000p3m3_Sw.c phalI18000p3m3_Sw.h phalI18000p3m3_Sw_Int.c phalI18000p3m3_Sw_Int.h
  group NxpNfcLib/comps/phalICode/src
    ../NxpNfcRdLib/comps/phalICode/src/: phalICode.c phalICode_Int.c phalICode_Int.h
  group NxpNfcLib/comps/phalICode/src/Sw
    ../NxpNfcRdLib/comps/phalICode/src/Sw/: phalI15693_Sw_Int.h phalICode_Sw.c phalICode_Sw.h
  group NxpNfcLib/comps/phalMfc/src
    ../NxpNfcRdLib/comps/phalMfc/src/: phalMfc.c phalMfc_Int.c phalMfc_Int.h
  group NxpNfcLib/comps/phalMfc/src/Sw
    ../NxpNfcRdLib/comps/phalMfc/src/Sw/: phalMfc_Sw.c phalMfc_Sw.h
  group NxpNfcLib/comps/phalMfdf/src
    ../NxpNfcRdLib/comps/phalMfdf/src/: phalMfdf.c phalMfdf_Int.c phalMfdf_Int.h
  group NxpNfcLib/comps/phalMfdf/src/Sw
    ../NxpNfcRdLib/comps/phalMfdf/src/Sw/: phalMfdf_Sw.c phalMfdf_Sw.h phalMfdf_Sw_Int.c phalMfdf_Sw_Int.h
  group NxpNfcLib/comps/phalMful/src
    ../NxpNfcRdLib/comps/phalMful/src/: phalMful.c phalMful_Int.c phalMful_Int.h
  group NxpNfcLib/comps/phalMful/src/Sw
    ../NxpNfcRdLib/comps/phalMful/src/Sw/: phalMful_Sw.c phalMful_Sw.h
  group NxpNfcLib/comps/phalT1T/src
    ../NxpNfcRdLib/comps/phalT1T/src/: phalT1T.c
  group NxpNfcLib/comps/phalT1T/src/Sw
    ../NxpNfcRdLib/comps/phalT1T/src/Sw/: phalT1T_Sw.c phalT1T_Sw.h
  group NxpNfcLib/comps/phalTop/src
    ../NxpNfcRdLib/comps/phalTop/src/: phalTop.c
  group NxpNfcLib/comps/phalTop/src/Sw
    ../NxpNfcRdLib/comps/phalTop/src/Sw/: phalTop_Sw.c phalTop_Sw.h phalTop_Sw_Int_T1T.c phalTop_Sw_Int_T1T.h phalTop_Sw_Int_T2T.c phalTop_Sw_Int_T2T.h phalTop_Sw_Int_T3T.c phalTop_Sw_Int_T3T.h phalTop_Sw_Int_T4T.c phalTop_Sw_Int_T4T.h phalTop_Sw_Int_T5T.c phalTop_Sw_Int_T5T.h
  group NxpNfcLib/comps/phceT4T/src
    ../NxpNfcRdLib/comps/phceT4T/src/: phceT4T.c
  group NxpNfcLib/comps/phceT4T/src/Sw
    ../NxpNfcRdLib/comps/phceT4T/src/Sw/: phceT4T_Sw.c phceT4T_Sw.h phceT4T_Sw_Int.c phceT4T_Sw_Int.h
  group NxpNfcLib/comps/phhalHw/src
    ../NxpNfcRdLib/comps/phhalHw/src/: phhalHw.c
  group NxpNfcLib/comps/phhalHw/src/PN7462AU
    ../NxpNfcRdLib/comps/phhalHw/src/PN7462AU/: phhalHw_PN7462AU.c phhalHw_PN7462AU.h phhalHw_PN7462AU_Int.c phhalHw_PN7462AU_Int.h
  group NxpNfcLib/comps/phKeyStore/src
    ../NxpNfcRdLib/comps/phKeyStore/src/: phKeyStore.c phKeyStore_Int.h
  group NxpNfcLib/comps/phKeyStore/src/Sw
    ../NxpNfcRdLib/comps/phKeyStore/src/Sw/: phKeyStore_Sw.c phKeyStore_Sw.h phKeyStore_Sw_Int.h
  group NxpNfcLib/comps/phlnLlcp/src
    ../NxpNfcRdLib/comps/phlnLlcp/src/: phlnLlcp.c
  group NxpNfcLib/comps/phlnLlcp/src/Sw
    ../NxpNfcRdLib/comps/phlnLlcp/src/Sw/: phlnLlcp_Sw.c phlnLlcp_Sw.h phlnLlcp_Sw_Int.c phlnLlcp_Sw_Int.h phlnLlcp_Sw_Mac.c phlnLlcp_Sw_Mac.h phlnLlcp_Sw_Transport.c phlnLlcp_Sw_Transport_Connection.c phlnLlcp_Sw_Transport_Connectionless.c phlnLlcp_Timers.c phlnLlcp_Timers.h
  group NxpNfcLib/comps/phLog/src
    ../NxpNfcRdLib/comps/phLog/src/: phLog.c phLog_Int.h
  group NxpNfcLib/comps/phnpSnep/src
    ../NxpNfcRdLib/comps/phnpSnep/src/: phnpSnep.c
  group NxpNfcLib/comps/phnpSnep/src/Sw
    ../NxpNfcRdLib/comps/phnpSnep/src/Sw/: phnpSnep_Sw.c phnpSnep_Sw.h
  group NxpNfcLib/comps/phpalFelica/src
    ../NxpNfcRdLib/comps/phpalFelica/src/: phpalFelica.c
  group NxpNfcLib/comps/phpalFelica/src/Sw
    ../NxpNfcRdLib/comps/phpalFelica/src/Sw/: phpalFelica_Sw.c phpalFelica_Sw.h phpalFelica_Sw_Int.h
  group NxpNfcLib/comps/phpalI14443p3a/src
    ../NxpNfcRdLib/comps/phpalI14443p3a/src/: phpalI14443p3a.c
  group NxpNfcLib/comps/phpalI14443p3a/src/Sw
    ../NxpNfcRdLib/comps/phpalI14443p3a/src/Sw/: phpalI14443p3a_Sw.c phpalI14443p3a_Sw.h phpalI14443p3a_Sw_Int.h
  group NxpNfcLib/comps/phpalI14443p3b/src
    ../NxpNfcRdLib/comps/phpalI14443p3b/src/: phpalI14443p3b.c
  group NxpNfcLib/comps/phpalI14443p3b/src/Sw
    ../NxpNfcRdLib/comps/phpalI14443p3b/src/Sw/: phpalI14443p3b_Sw.c phpalI14443p3b_Sw.h phpalI14443p3b_Sw_Int.h
  group NxpNfcLib/comps/phpalI14443p4/src
    ../NxpNfcRdLib/comps/phpalI14443p4/src/: phpalI14443p4.c
  group NxpNfcLib/comps/phpalI14443p4/src/Sw
    ../NxpNfcRdLib/comps/phpalI14443p4/src/Sw/: phpalI14443p4_Sw.c phpalI14443p4_Sw.h phpalI14443p4_Sw_Int.h
  group NxpNfcLib/comps/phpalI14443p4a/src
    ../NxpNfcRdLib/comps/phpalI14443p4a/src/: phpalI14443p4a.c
  group NxpNfcLib/comps/phpalI14443p4a/src/Sw
    ../NxpNfcRdLib/comps/phpalI14443p4a/src/Sw/: phpalI14443p4a_Sw.c phpalI14443p4a_Sw.h phpalI14443p4a_Sw_Int.h
  group NxpNfcLib/comps/phpalI14443p4mC/src
    ../NxpNfcRdLib/comps/phpalI14443p4mC/src/: phpalI14443p4mC.c
  group NxpNfcLib/comps/phpalI14443p4mC/src/Sw
    ../NxpNfcRdLib/comps/phpalI14443p4mC/src/Sw/: phpalI14443p4mC_Sw.c phpalI14443p4mC_Sw.h phpalI14443p4mC_Sw_Int.c phpalI14443p4mC_Sw_Int.h
  group NxpNfcLib/comps/phpalI18000p3m3/src
    ../NxpNfcRdLib/comps/phpalI18000p3m3/src/: phpalI18000p3m3.c
  group NxpNfcLib/comps/phpalI18000p3m3/src/Sw
    ../NxpNfcRdLib/comps/phpalI18000p3m3/src/Sw/: phpalI18000p3m3_Sw.c phpalI18000p3m3_Sw.h phpalI18000p3m3_Sw_Int.h
  group NxpNfcLib/comps/phpalI18092mPI/src
    ../NxpNfcRdLib/comps/phpalI18092mPI/src/: phpalI18092mPI.c
  group NxpNfcLib/comps/phpalI18092mPI/src/Sw
    ../NxpNfcRdLib/comps/phpalI18092mPI/src/Sw/: phpalI18092mPI_Sw.c phpalI18092mPI_Sw.h phpalI18092mPI_Sw_Int.c phpalI18092mPI_Sw_Int.h
  group NxpNfcLib/comps/phpalI18092mT/src
    ../NxpNfcRdLib/comps/phpalI18092mT/src/: phpalI18092mT.c
  group NxpNfcLib/comps/phpalI18092mT/src/Sw
    ../NxpNfcRdLib/comps/phpalI18092mT/src/Sw/: phpalI18092mT_Sw.c phpalI18092mT_Sw.h phpalI18092mT_Sw_Int.c phpalI18092mT_Sw_Int.h
  group NxpNfcLib/comps/phpalMifare/src
    ../NxpNfcRdLib/comps/phpalMifare/src/: phpalMifare.c phpalMifare_Int.h
  group NxpNfcLib/comps/phpalMifare/src/Sw
    ../NxpNfcRdLib/comps/phpalMifare/src/Sw/: phpalMifare_Sw.c phpalMifare_Sw.h
  group NxpNfcLib/comps/phpalSli15693/src
    ../NxpNfcRdLib/comps/phpalSli15693/src/: phpalSli15693.c
  group NxpNfcLib/comps/phpalSli15693/src/Sw
    ../NxpNfcRdLib/comps/phpalSli15693/src/Sw/: phpalSli15693_Sw.c phpalSli15693_Sw.h phpalSli15693_Sw_Int.h
  group NxpNfcLib/comps/phTools/src
    ../NxpNfcRdLib/comps/phTools/src/: phTools.c phTools_Q.c
  group NxpNfcLib/intfs
    ../NxpNfcRdLib/intfs/: NxpRdLib_Ver.h phacDiscLoop.h phalFelica.h phalI15693.h phalI18000p3m3.h phalMfc.h phalMfdf.h phalMful.h phalT1T.h phalTop.h phceT4T.h phhalHw.h phKeyStore.h phlnLlcp.h phLog.h phnpSnep.h phOsal.h phpalEpcUid.h phpalFelica.h phpalI14443p3a.h phpalI14443p3b.h phpalI14443p4.h phpalI14443p4a.h phpalI14443p4mC.h phpalI18000p3m3.h phpalI18092mPI.h phpalI18092mT.h phpalMifare.h phpalSli15693.h phPlatform.h phTools.h
  group phCommon/inc
    ../PN7462AU/phCommon/inc/: ph_BinaryNumbers.h ph_Config.h ph_Datatypes.h ph_Log.h ph_MemoryMap.h ph_NxpBuild.h ph_NxpBuild_Default.h ph_Platform.h ph_RefDefs.h ph_Reg.h ph_Status.h ph_TypeDefs.h phCfg_EE.h phFlashBoot.h phFlashBoot_Event.h phhalClkGen.h phhalCrc.h phhalCt.h phhalEeprom.h phhalFlash.h phhalGpio.h phhalHif.h phhalHif_Usb.h phhalI2CM.h phhalNvic.h phhalPcr.h phhalPmu.h phhalRf.h phhalRf_LP_Int.h phhalRng.h phhalSPIM.h phhalSyncCt.h phhalSyncCt_I2C.h phhalSyncCt_S10.h phhalSyncCt_S9.h phhalSysSer.h phhalTimer.h phhalWdt.h phLED.h phRtos.h phSysSv_Data.h phUser.h PN7462AU_ROM3.h PN7462AU_Ver.h
  group phCommon/inc/PN7462AU
    ../PN7462AU/phCommon/inc/PN7462AU/: PN7462AU_clif.h PN7462AU_clkgen.h PN7462AU_crc.h PN7462AU_ctip.h PN7462AU_eectrl.h PN7462AU_hif.h PN7462AU_i2cm.h PN7462AU_pcr.h PN7462AU_pmu.h PN7462AU_regcore.h PN7462AU_rng.h PN7462AU_spim.h PN7462AU_timers.h PN7462AU_usb.h
  group phCommon/inc/wrapper
    ../PN7462AU/phCommon/inc/wrapper/: phRtos_NoRtos.h phRtos_RTOS.h
  group phCommon/src
    ../PN7462AU/phCommon/src/: phUser.c
  group phOsal
    ../phOsal/src/Freertos/: phOsal_Freertos.c
    ../phOsal/src/NullOs/: phOsal_NullOs.c
    ../phOsal/src/NullOs/portable/: phOsal_Port_PN74xxxx.c
  group phRtos
    ../FreeRTOS/: phFreeRTOSConfig.c
  group phRtos/src
    ../PN7462AU/phRtos/src/: phRtos_NoRtos.c phRtos_RTOS.c
  group PN7462AU/phBoot/src
    ../PN7462AU/phBoot/src/: phFlashBoot.c phFlashBoot_IAR.s phFlashBoot_VT.c
  group PN7462AU/phHal/phCfg/src
    ../PN7462AU/phHal/phCfg/src/: phCfg_EE.c phCfg_PF.c
  group PN7462AU/phHal/phhalClkGen/src
    ../PN7462AU/phHal/phhalClkGen/src/: phhalClkGen.c
  group PN7462AU/phHal/phhalCt/src
    ../PN7462AU/phHal/phhalCt/src/: phhalCt.c phhalCt_Activate.c phhalCt_Common.c phhalCt_Event.c phhalCt_Event.h phhalCt_Int.h phhalCt_Transceive.c
  group PN7462AU/phHal/phhalFlash/src
    ../PN7462AU/phHal/phhalFlash/src/: phhalFlash.c
  group PN7462AU/phHal/phhalHif/src
    ../PN7462AU/phHal/phhalHif/src/: phhalHif.c phhalHif_Int.h
  group PN7462AU/phHal/phhalPcr/src
    ../PN7462AU/phHal/phhalPcr/src/: phhalGpio.c phhalPcr.c
  group PN7462AU/phHal/phhalPmu/src
    ../PN7462AU/phHal/phhalPmu/src/: phhalPmu.c
  group PN7462AU/phHal/phhalRf/src
    ../PN7462AU/phHal/phhalRf/src/: phhalRf_Event.c phhalRf_Event.h phhalRf_LP_V.c phhalRf_LP_V.h
  group PN7462AU/phHal/phhalTimer/src
    ../PN7462AU/phHal/phhalTimer/src/: phhalTimer.c phhalTimer_Int.h
  group PN7462AU/phHal/phhalWdt/inc
    ../PN7462AU/phHal/phhalWdt/inc/: phhalWdt.h
  group PN7462AU/phHal/phhalWdt/src
    ../PN7462AU/phHal/phhalWdt/src/: phhalWdt.c
  group PN7462AU/phHal/phLED/src
    ../PN7462AU/phHal/phLED/src/: phLED.c
  group PN7462AU/phROMIntf/phhalSysSer/src
    ../PN7462AU/phROMIntf/phhalSysSer/src/: phhalSysSer_IAR.s
  group src
    src/: phExPos.c phExPos_Clif.c phExPos_Ct.c phExPos_Log.c phExPos_Log.h phExPos_Poll.c phExPos_SPIHIF.c phExPos_TypeAEMV.c phExPos_Utils.c
