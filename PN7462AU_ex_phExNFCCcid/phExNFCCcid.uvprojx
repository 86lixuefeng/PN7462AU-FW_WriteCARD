# Keil uVision project phExNFCCcid.uvprojx, settings and files
target Debug (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: PN7462AU-C3-00 NXP
  pack: NXP.PN7xxxxx.0.9.0
  cpu: IROM(0x00203000,0x00027800) IRAM(0x00100020,0x2EE0) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: phExNFCCcid
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=$L@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 wLevel=2
  c define: __PN74XXXX__ PHFL_APP_NXBUILD_CONFIG PHFL_LOG_ENABLE=0 PHFL_LLCP_SNEP_ENABLE PH_OSAL_FREERTOS
  c misc: --diag_suppress=1295
  c include: ..\PN7462AU\external\USBD_ROMStack\inc;..\PN7462AU\phCommon\inc;..\NxpNfcRdLib\intfs;..\PN7462AU\phBoot\inc;..\PN7462AU\phHal\phCfg\inc;..\PN7462AU\phHal\phLED\inc;..\PN7462AU\phHal\phhalClkGen\inc;..\PN7462AU\phHal\phhalCrc\inc;..\PN7462AU\phHal\phhalEeprom\inc;..\PN7462AU\phHal\phhalFlash\inc;..\PN7462AU\phHal\phhalHif\inc;..\PN7462AU\phHal\phhalI2CM\inc;..\PN7462AU\phHal\phhalPcr\inc;..\PN7462AU\phHal\phhalPmu\inc;..\PN7462AU\phHal\phhalRf\inc;..\PN7462AU\phHal\phhalRng\inc;..\PN7462AU\phHal\phhalSPIM\inc;..\PN7462AU\phHal\phhalTimer\inc;..\PN7462AU\phHal\phhalWdt\inc;..\PN7462AU\phROMIntf\phhalSysSer\inc;..\PN7462AU\external\CCID\inc;..\FreeRTOS\include;.\inc;..\PN7462AU\phRtos\inc;..\FreeRTOS\portable\RVDS\ARM_CM0;..\DAL\boards;..\DAL\inc;..\DAL\cfg;..\phOsal\inc
  library: MicroLIB
  memory RVCT4: ROM 0x203000 size 0x27800
  memory RVCT9: RAM 0x100020 size 0x2ee0
  link misc: ..\PN7462AU\phHal\phhalRf\lib\libphhalRf_armcc.lib ..\PN7462AU\external\USBD_ROMStack\lib\libusbd_armcc.lib
  group phExNFCCcid
    ./src/: phExNFCCcid.c phExNFCCcid_15693.c phExNFCCcid_18000p3m3.c phExNFCCcid_Clif.c phExNFCCcid_Descriptors.c phExNFCCcid_Felica.c phExNFCCcid_LED.c phExNFCCcid_Log.c phExNFCCcid_MiFareClassic.c phExNFCCcid_MiFareUltraLight.c phExNFCCcid_Poll.c phExNFCCcid_TypeA_L4Exchange.c phExNFCCcid_TypeB_L4Exchange.c phExNFCCcid_Usb_If.c phExNFCCcid_UsbCcid.c phExNFCCcid_UsbCcid_PCSC.c phExNFCCcid_UsbCcid_Process.c phExNFCCcid_UsbUser.c phExNFCCcid_LLCP_Client.c
    ./inc/: APP_NxpBuild.h app_usbd_cfg.h phExNFCCcid.h phExNFCCcid_15693.h phExNFCCcid_18000p3m3.h phExNFCCcid_Cfg.h phExNFCCcid_Clif.h phExNFCCcid_Descriptors.h phExNFCCcid_Felica.h phExNFCCcid_MiFareClassic.h phExNFCCcid_MiFareUltraLight.h phExNFCCcid_Poll.h phExNFCCcid_TypeA_L4Exchange.h phExNFCCcid_TypeB_L4Exchange.h phExNFCCcid_Usb_If.h phExNFCCcid_UsbCcid.h phExNFCCcid_LLCP_Client.h phExNFCCcid_LLCP_NDEFMsg.h
  group NxpNfcLib-AL
    ../NxpNfcRdLib/comps/phalMful/src/Sw/: phalMful_Sw.c
    ../NxpNfcRdLib/comps/phalMful/src/: phalMful_Int.c phalMful.c
    ../NxpNfcRdLib/comps/phacDiscLoop/src/: phacDiscLoop.c
    ../NxpNfcRdLib/comps/phacDiscLoop/src/Sw/: phacDiscLoop_Sw.c phacDiscLoop_Sw_Int.c phacDiscLoop_Sw_Int_A.c phacDiscLoop_Sw_Int_B.c phacDiscLoop_Sw_Int_F.c phacDiscLoop_Sw_Int_I18000p3m3.c phacDiscLoop_Sw_Int_V.c
    ../NxpNfcRdLib/comps/phalFelica/src/: phalFelica.c
    ../NxpNfcRdLib/comps/phalFelica/src/Sw/: phalFelica_Sw.c
    ../NxpNfcRdLib/comps/phalICode/src/: phalICode.c phalICode_Int.c
    ../NxpNfcRdLib/comps/phalICode/src/Sw/: phalICode_Sw.c
    ../NxpNfcRdLib/comps/phalI18000p3m3/src/: phalI18000p3m3.c
    ../NxpNfcRdLib/comps/phalI18000p3m3/src/Sw/: phalI18000p3m3_Sw.c phalI18000p3m3_Sw_Int.c
    ../NxpNfcRdLib/comps/phalMfc/src/: phalMfc.c phalMfc_Int.c
    ../NxpNfcRdLib/comps/phalMfc/src/Sw/: phalMfc_Sw.c
    ../NxpNfcRdLib/comps/phalMfdf/src/: phalMfdf.c phalMfdf_Int.c
    ../NxpNfcRdLib/comps/phalMfdf/src/Sw/: phalMfdf_Sw.c phalMfdf_Sw_Int.c
  group NxpNfcLib-HAL
    ../NxpNfcRdLib/comps/phhalHw/src/: phhalHw.c
    ../NxpNfcRdLib/comps/phhalHw/src/PN7462AU/: phhalHw_PN7462AU.c phhalHw_PN7462AU_Int.c
  group NxpNfcLib-Common
    ../NxpNfcRdLib/comps/phKeyStore/src/: phKeyStore.c
    ../NxpNfcRdLib/comps/phKeyStore/src/Sw/: phKeyStore_Sw.c
    ../NxpNfcRdLib/comps/phTools/src/: phTools.c phTools_Q.c
  group NxpNfcLib-PAL
    ../NxpNfcRdLib/comps/phpalFelica/src/: phpalFelica.c
    ../NxpNfcRdLib/comps/phpalFelica/src/Sw/: phpalFelica_Sw.c
    ../NxpNfcRdLib/comps/phpalI14443p3a/src/: phpalI14443p3a.c
    ../NxpNfcRdLib/comps/phpalI14443p3a/src/Sw/: phpalI14443p3a_Sw.c
    ../NxpNfcRdLib/comps/phpalI14443p3b/src/: phpalI14443p3b.c
    ../NxpNfcRdLib/comps/phpalI14443p3b/src/Sw/: phpalI14443p3b_Sw.c
    ../NxpNfcRdLib/comps/phpalI14443p4/src/: phpalI14443p4.c
    ../NxpNfcRdLib/comps/phpalI14443p4/src/Sw/: phpalI14443p4_Sw.c
    ../NxpNfcRdLib/comps/phpalI14443p4a/src/: phpalI14443p4a.c
    ../NxpNfcRdLib/comps/phpalI14443p4a/src/Sw/: phpalI14443p4a_Sw.c
    ../NxpNfcRdLib/comps/phpalI18000p3m3/src/: phpalI18000p3m3.c
    ../NxpNfcRdLib/comps/phpalI18000p3m3/src/Sw/: phpalI18000p3m3_Sw.c
    ../NxpNfcRdLib/comps/phpalI18092mPI/src/: phpalI18092mPI.c
    ../NxpNfcRdLib/comps/phpalI18092mPI/src/Sw/: phpalI18092mPI_Sw.c phpalI18092mPI_Sw_Int.c
    ../NxpNfcRdLib/comps/phpalMifare/src/: phpalMifare.c
    ../NxpNfcRdLib/comps/phpalMifare/src/Sw/: phpalMifare_Sw.c
    ../NxpNfcRdLib/comps/phpalSli15693/src/: phpalSli15693.c
    ../NxpNfcRdLib/comps/phpalSli15693/src/Sw/: phpalSli15693_Sw.c
  group external-Usb
    ../PN7462AU/external/CCID/src/: mw_usbd_cciduser.c
  group external-Rtos
    ../FreeRTOS/: event_groups.c list.c queue.c tasks.c timers.c heap_3.c phFreeRTOSConfig.c
    ../FreeRTOS/portable/RVDS/ARM_CM0/: port.c
  group Boot
    ../PN7462AU/phBoot/src/: phFlashBoot.c
  group Cfg
    ../PN7462AU/phHal/phCfg/src/: phCfg_EE.c phCfg_PF.c
  group ClkGen
    ../PN7462AU/phHal/phhalClkGen/src/: phhalClkGen.c
  group Common
    ../PN7462AU/phCommon/src/: phUser.c
  group Hif
    ../PN7462AU/phHal/phhalHif/src/: phhalHif_Usb.c
  group LED
    ../PN7462AU/phHal/phLED/src/: phLED.c
  group PCR
    ../PN7462AU/phHal/phhalPcr/src/: phhalGpio.c phhalPcr.c
  group Rf
    ../PN7462AU/phHal/phhalRf/src/: phhalRf_Event.c phhalRf_LP_V.c
  group PMU
    ../PN7462AU/phHal/phhalPmu/src/: phhalPmu.c
  group Rtos
    ../PN7462AU/phRtos/src/: phRtos_NoRtos.c phRtos_RTOS.c
  group SystemServices
    ../PN7462AU/phROMIntf/phhalSysSer/src/: phhalSysSer_DS5.c
  group Timers
    ../PN7462AU/phHal/phhalTimer/src/: phhalTimer.c
  group NxpNfcLib-Llcp
    ../NxpNfcRdLib/comps/phlnLlcp/src/Sw/: phlnLlcp_Sw.c phlnLlcp_Sw_Int.c phlnLlcp_Sw_Mac.c phlnLlcp_Sw_Transport.c phlnLlcp_Sw_Transport_Connection.c phlnLlcp_Sw_Transport_Connectionless.c phlnLlcp_Timers.c
    ../NxpNfcRdLib/comps/phlnLlcp/src/: phlnLlcp.c
  group NxpNfcLib-Snep
    ../NxpNfcRdLib/comps/phnpSnep/src/: phnpSnep.c
    ../NxpNfcRdLib/comps/phnpSnep/src/Sw/: phnpSnep_Sw.c
  group DAL
    ../DAL/src/PN74xxxx/: phDriver_PN74xxxx.c
  group phOsal
    ../phOsal/src/Freertos/: phOsal_Freertos.c
    ../phOsal/src/NullOs/: phOsal_NullOs.c
    ../phOsal/src/NullOs/portable/: phOsal_Port_PN74xxxx.c
target Release (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: PN7462AU-C3-00 NXP
  pack: NXP.PN7xxxxx.0.9.0
  cpu: as above
  output: phExNFCCcid
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=$L@L.bin !L
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: as above
  c misc: --diag_suppress=1295
  c include: ..\PN7462AU\external\USBD_ROMStack\inc;..\PN7462AU\phCommon\inc;..\NxpNfcRdLib\intfs;..\PN7462AU\phBoot\inc;..\PN7462AU\phHal\phCfg\inc;..\PN7462AU\phHal\phLED\inc;..\PN7462AU\phHal\phhalClkGen\inc;..\PN7462AU\phHal\phhalCrc\inc;..\PN7462AU\phHal\phhalEeprom\inc;..\PN7462AU\phHal\phhalFlash\inc;..\PN7462AU\phHal\phhalHif\inc;..\PN7462AU\phHal\phhalI2CM\inc;..\PN7462AU\phHal\phhalPcr\inc;..\PN7462AU\phHal\phhalPmu\inc;..\PN7462AU\phHal\phhalRf\inc;..\PN7462AU\phHal\phhalRng\inc;..\PN7462AU\phHal\phhalSPIM\inc;..\PN7462AU\phHal\phhalTimer\inc;..\PN7462AU\phHal\phhalWdt\inc;..\PN7462AU\phROMIntf\phhalSysSer\inc;..\PN7462AU\external\CCID\inc;..\FreeRTOS\include;.\inc;..\PN7462AU\phRtos\inc;..\FreeRTOS\portable\RVDS\ARM_CM0;..\phOsal\inc;..\DAL\boards;..\DAL\inc;..\DAL\cfg
  library: MicroLIB
  memory RVCT4: ROM 0x203000 size 0x27800
  memory RVCT9: RAM 0x100020 size 0x2ee0
  link misc: as above
software components: Device:Startup 0.9.0
